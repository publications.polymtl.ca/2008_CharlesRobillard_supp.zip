simulink model "Matrice"  (Simulink 6.0)
settings: Solver=ode45  StartTime=0  StopTime=17*t0  RelTol=1e-3
values from neighbouring files (symbols this model uses):
  beta = 0.95    [Constantes.m]    (also in ConstantesBck.m; ResCourV1.m = 1; ResCrV1.m = 1; ResEnerV1.m = 1)
  Cmem = 1E-6*Sm*(1-b)    (= 2.826e-08)    [Constantes.m]    (also in ConstantesBck.m = 3.14e-11; ImpedanceZtissus.m = 4e-08; Ztissus.m = 4e-08; CalculCharge.m = 1)
  N = [6,8,5,5,7,1,2,6,9,1,1,9,4,8,8,7]    [Constantes.m]    (also in ConstantesBck.m; ImpedanceZtissus.m = 100; Ztissus.m = 100; charge.m = N(:,2))
  rapportIE = 10    [Constantes.m]
  Rcan = 6.398E3*Sm*(1-b)    (= 180.80748)    [Constantes.m]    (also in ConstantesBck.m = 0.03454; ImpedanceZtissus.m = 44; Ztissus.m = 44)
  t0 = 2E-3    (= 0.002)    [Constantes.m]    (also in ConstantesBck.m = 0.001)
undefined symbols (not defined in the file or in its folder): ln
(part 2 of 2)

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZietVar ==
  InZiet : Inport  Orientation=left  Port=1  LatchInput=off
  Constant{,1..2,4} (4 alike) : Constant
  Contrôleur : Stateflow chart  Orientation=left
  Divide{1..4} (4 alike) : Product  Inputs=*/  OutScaling=2^-10
  Rct : Fcn  Expr=u*(3147.77*(1/((1E6*abs(u))^0.7199)))*1000
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Zcpa : Subsystem
  Zw : Subsystem
  OutZiet : Outport  Orientation=left
  wires:
  Constant/1 -> Divide1/1
  Constant1/1 -> Divide2/1
  Constant2/1 -> Divide3/1
  Zcpa/1(OutZcpa) -> Divide3/2
  Zw/1(OutZw) -> Divide2/2
  Rct/1 -> Divide1/2
  Divide3/1 -> Sum/1
  Constant4/1 -> Divide4/1
  Divide2/1 -> Sum/2
  Sum/1 -> Sum1/1
  Divide1/1 -> Sum1/2
  Sum1/1 -> Divide4/2
  Contrôleur/2(temp) -> Rct/1, Zw/1(InZw), Zcpa/1(InZcpa)
  InZiet/1 -> Contrôleur/1(u)
  Contrôleur/1(y) -> OutZiet/1
  Divide4/1 -> Contrôleur/2(calc)

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZmembraneVar ==
  InZmem : Inport  Orientation=left  Port=1  LatchInput=off
  Constant : Constant
  Constant1 : Constant
  Constant2 : Constant
  Contrôleur : Stateflow chart  Orientation=left
  Divide : Product  Inputs=*/  OutScaling=2^-10
  Divide1 : Product  Inputs=*/  OutScaling=2^-10
  Divide2 : Product  Inputs=*/  OutScaling=2^-10
  Gain : Gain  Gain=2
  Rext : Fcn  Expr=u*(1.6342*((abs(u)*1E6)^0.1267))*1E3
  Rint : Fcn  Expr=u*(1.6342*((abs(u)*1E6)^0.1267))*1E3/rapportIE
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Transfer Fcn : TransferFcn  Numerator=[Rcan]  Denominator=[Rcan*Cmem 1]
  OutZmem : Outport  Orientation=left
  wires:
  Gain/1 -> Transfer Fcn/1
  Transfer Fcn/1 -> Sum/1
  Sum/1 -> Divide/2
  Rext/1 -> Divide1/2
  Constant1/1 -> Divide/1
  Constant/1 -> Divide1/1
  Divide/1 -> Sum1/1
  Constant2/1 -> Divide2/1
  Sum1/1 -> Divide2/2
  Rint/1 -> Sum/2
  Divide1/1 -> Sum1/2
  Contrôleur/2(temp) -> Rext/1, Rint/1, Gain/1
  Divide2/1 -> Contrôleur/2(calc)
  InZmem/1 -> Contrôleur/1(u)
  Contrôleur/1(y) -> OutZmem/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA1/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA1/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA2/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA2/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA3/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice0/ZtotVarNPA3/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA1/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA1/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA2/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA2/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA3/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice1/ZtotVarNPA3/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA1/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA1/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA2/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA2/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA3/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice2/ZtotVarNPA3/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA1/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA1/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA2/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA2/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZietVar/Zcpa ==
  InZcpa : Inport  Port=1  LatchInput=off
  Cdl : Fcn  Expr=u*1E9/(918.15-80.854*ln(abs(u)*1E6))
  Fcn : Fcn  Expr=u(1)^beta
  Integrator : Integrator
  OutZcpa : Outport
  wires:
  Integrator/1 -> Fcn/1
  InZcpa/1 -> Cdl/1
  Fcn/1 -> OutZcpa/1
  Cdl/1 -> Integrator/1

== system Matrice/Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZietVar/Zw ==
  InZw : Inport  Port=1  LatchInput=off
  Gain : Gain  Gain=2
  Integrator : Integrator
  Math Function : Math  Operator=sqrt
  Product : Product
  sigma : Fcn  Expr=(67202-0.0688*((1E6*abs(u))^2)-11.273*(1E6*abs(u)))
  OutZw : Outport
  wires:
  Integrator/1 -> Math Function/1
  InZw/1 -> sigma/1, Gain/1
  Math Function/1 -> Product/1
  sigma/1 -> Product/2
  Product/1 -> OutZw/1
  Gain/1 -> Integrator/1

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function OSS ==
function [S0,Ref0,S1,Ref1,S2,Ref2,S3,Ref3,S4,Ref4,S5,Ref5,S6,Ref6,S7,Ref7,S8,Ref8,S9,Ref9,S10,Ref10,S11,Ref11,S12,Ref12,S13,Ref13,S14,Ref14,S15,Ref15,MatCourant] = fcn(u0,u1,u2,u3,u4,u5,u6,u7,u8,u9,u10,u11,u12,u13,u14,u15,tc0,tc1,tc2,dyn,rst)
%Fonction qui détermine les endroits à stimuler pour obtenir une puissance 
%moyenne par canal minimal

%Valeur utilisée
Vdd=3.3;
Imax=200E-6;

%Enregistrement de l'indice et de l'amplitude pour chaque canal
IndAmpChan0=[1,2,3,4;u0,u1,u2,u3];
IndAmpChan1=[5,6,7,8;u4,u5,u6,u7];
IndAmpChan2=[9,10,11,12;u8,u9,u10,u11];
IndAmpChan3=[13,14,15,16;u12,u13,u14,u15];

%Premier tri
for k=1:2
    for i=1:3
        if(IndAmpChan0(2,i)>IndAmpChan0(2,i+1))
            temp=IndAmpChan0(:,i+1);
            IndAmpChan0(:,i+1)=IndAmpChan0(:,i);
            IndAmpChan0(:,i)=temp;        
        end
        if(IndAmpChan1(2,i)<IndAmpChan1(2,i+1))
            temp=IndAmpChan1(:,i+1);
            IndAmpChan1(:,i+1)=IndAmpChan1(:,i);
            IndAmpChan1(:,i)=temp;        
        end    
        if(IndAmpChan2(2,i)>IndAmpChan2(2,i+1))
            temp=IndAmpChan2(:,i+1);
            IndAmpChan2(:,i+1)=IndAmpChan2(:,i);
            IndAmpChan2(:,i)=temp;        
        end    
        if(IndAmpChan3(2,i)<IndAmpChan3(2,i+1))
            temp=IndAmpChan3(:,i+1);
            IndAmpChan3(:,i+1)=IndAmpChan3(:,i);
            IndAmpChan3(:,i)=temp;        
        end        
    end
end

%On regroupe les lignes 2 par deux
sump1=[0,0,0,0];
sump2=[0,0,0,0];
for i=1:4
    sump1(i)=IndAmpChan0(2,i)+IndAmpChan1(2,i);
    sump2(i)=IndAmpChan2(2,i)+IndAmpChan3(2,i);
end

%2e tri
for k=1:2
    for i=1:3
        if(sump1(i)>sump1(i+1))
            temp=IndAmpChan0(:,i+1);
            IndAmpChan0(:,i+1)=IndAmpChan0(:,i);
            IndAmpChan0(:,i)=temp; 
            
            temp=IndAmpChan1(:,i+1);
            IndAmpChan1(:,i+1)=IndAmpChan1(:,i);
            IndAmpChan1(:,i)=temp;
            
            tempo=sump1(i+1);
            sump1(i+1)=sump1(i);
            sump1(i)=tempo;            
        end  
        if(sump2(i)<sump2(i+1))
            temp=IndAmpChan2(:,i+1);
            IndAmpChan2(:,i+1)=IndAmpChan2(:,i);
            IndAmpChan2(:,i)=temp;        
            
            temp=IndAmpChan3(:,i+1);
            IndAmpChan3(:,i+1)=IndAmpChan3(:,i);
            IndAmpChan3(:,i)=temp;        
            
            tempo=sump2(i+1);
            sump2(i+1)=sump2(i);
            sump2(i)=tempo;             
        end   
    end
end

if(tc0==0)
    Signe=-1;
else
    Signe=1;
end

%Initialisation des tableaux de sorties
SOut=[0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0];

%Détermination des sorties actives
if(tc2 == 0)
    if(tc1 == 0)
        i=1;
    else
        i=2;
    end
else
    if(tc1 == 0)
        i=3;
    else
        i=4;
    end    
end

RefOut=0;
if not(rst == 0)
    %Calcul des valeurs à sortir
    %La référence se doit d'être la même puisqu'il ne s'agit que d'une seule électrode
    SOut(IndAmpChan0(1,i))=Signe*Imax*IndAmpChan0(2,i)/10;
    SOut(IndAmpChan1(1,i))=Signe*Imax*IndAmpChan1(2,i)/10;
    SOut(IndAmpChan2(1,i))=Signe*Imax*IndAmpChan2(2,i)/10;
    SOut(IndAmpChan3(1,i))=Signe*Imax*IndAmpChan3(2,i)/10;

    RefOut=-1*Signe*Vdd*dyn;
end

%Assignation des sorties
S0=SOut(1);
Ref0=RefOut;
S1=SOut(2);
Ref1=RefOut;
S2=SOut(3);
Ref2=RefOut;
S3=SOut(4);
Ref3=RefOut;
S4=SOut(5);
Ref4=RefOut;
S5=SOut(6);
Ref5=RefOut;
S6=SOut(7);
Ref6=RefOut;
S7=SOut(8);
Ref7=RefOut;
S8=SOut(9);
Ref8=RefOut;
S9=SOut(10);
Ref9=RefOut;
S10=SOut(11);
Ref10=RefOut;
S11=SOut(12);
Ref11=RefOut;
S12=SOut(13);
Ref12=RefOut;
S13=SOut(14);
Ref13=RefOut;
S14=SOut(15);
Ref14=RefOut;
S15=SOut(16);
Ref15=RefOut;
MatCourant=SOut;

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA1/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA1/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA2/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA1/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA1/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA2/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA2/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA3/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice1/ZtotVarNPA3/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA1/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA1/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA2/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA2/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA3/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA2/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA3/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice0/ZtotVarNPA3/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice2/ZtotVarNPA3/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA1/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA1/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA2/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA2/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZietVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end

== matlab function Matrice 4X4/ChanMatrice3/ZtotVarNPA3/ZmembraneVar/Contrôleur ==
function [y,temp] = fcn(u,calc)
% This block supports an embeddable subset of the MATLAB language.
% See the help menu for details. 

if u == 0
    y = 0;
    temp = 1E-6;
else
    y = calc;
    temp = u;
end
